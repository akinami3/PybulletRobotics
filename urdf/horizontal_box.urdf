Commit message: add box urdf

File: urdf/horizontal_box.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link box_link: geometry collision box size=5 1 1; visual box size=5 1 1
